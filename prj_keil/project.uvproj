# Keil uVision project project.uvproj, settings and files
target Debug (ARM-ADS)
  device: STM32F415RG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: Cygnoides
  AfterMake: fromelf --bin !L --output ..\BIN\CMS.BIN
  c flags: Optim=1 wLevel=2
  c define: STM32F4XX,STM32F405xx,USE_STDPERIPH_DRIVER,USE_USB_OTG_FS,GEXUEYUAN
  c include: .;..\library\STM32F4xx_Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\library\STM32F4xx_Libraries\CMSIS\Include;..\library\STM32F4xx_Libraries\CMSIS\ST\STM32F4xx\Include;..\library\STM32F4xx_Libraries\STM32F4xx_StdPeriph_Driver\inc;..\library\STM32F4xx_Libraries\STM32_USB_HOST_Library\Core\inc;..\library\STM32F4xx_Libraries\STM32_USB_OTG_Driver\inc;..\applications;..\drivers;..\os\rtthread\components\drivers\include;..\os\rtthread\components\finsh;..\os\rtthread\components\init;..\os\rtthread\components\rtgui\include;..\os\rtthread\include;..\os\rtthread\libcpu\arm\common;..\include;..\os\rtthread\libcpu\arm\cortex-m4;..\drivers\zigbee\coordinator\Include;..\drivers\zigbee\coordinator\TAL\Inc;..\drivers\zigbee\coordinator\TAL\AT86RF231\Inc;..\drivers\zigbee\coordinator\PAL\Inc;..\drivers\zigbee\coordinator\PAL\SAM3\Generic\Inc;..\drivers\zigbee\coordinator\PAL\SAM3\AT91SAM3S4C\Boards;..\drivers\zigbee\coordinator\PAL\SAM3\AT91SAM3S4C\Boards\RZ600_231_SAM3SEK;..\drivers\zigbee\coordinator\PAL\SAM3\Libraries;..\drivers\zigbee\coordinator\PAL\SAM3\Libraries\usb\include;..\drivers\zigbee\coordinator\MAC\Inc;..\drivers\zigbee\coordinator\Resources\Buffer_Management\Inc;..\drivers\zigbee\coordinator\Resources\Queue_Management\Inc;..\drivers\zigbee\coordinator\NWK\Inc;..\drivers\zigbee\coordinator\NWK\atmel_Inc;..\drivers\zigbee\coordinator\Applications;..\drivers\zigbee\coordinator\Applications\Helper_Files\SIO_Support\Inc;..\drivers\zigbee\coordinator\STM32F10x_StdPeriph_Lib_V3.5.0\Project\BSP\OS\uCOS-III
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --keep __rtmsym_*   --keep __fsym_* --keep __vsym_*   --keep __rt_init*
  group App
    ../app/vam/: cv_vam_main.c cv_vam_api.c cv_vam_lip.c cv_vam_lip_nmea.c cv_vam_rcp.c cv_vam_vsm.c cv_vam_util.c cv_vam_mda.c
    ../app/vsa/: cv_vsa_main.c cv_cpuusage.c
    ../app/sys/: cv_sys_main.c cv_sys_manager.c cv_sys_param.c cv_sys_sound_resource.c
    ../app/wnet/: cv_wnet_main.c cv_wnet_fp.c cv_wnet_llc.c cv_wnet_dsmp.c
  group Drivers
    ../drivers/: cv_drv_gps.c cv_drv_gsnr.c cv_drv_fls.c cv_drv_voc.c cv_drv_led.c cv_drv_key.c
  group Drivers_wifi
    ../drivers/wifi/: cv_drv_wifi_usb.c cv_drv_wifi_usb_device.c
    ../drivers/wifi/chips/ralink/common/: cmm_asic.c cmm_mac_usb.c rtmp_init.c rtmp_mcu.c rtmp_data.c rtusb_io.c rtusb_dev_id.c rt_rf.c rt_ate.c
    ../drivers/wifi/chips/ralink/chips/: rtmp_chip.c rt30xx.c rt3070.c
  group Bsp
    ../bsp/: board.c i2c.c led.c platform.c spi.c usart.c lsm303dlhc.c bma250e.c usb.c ili9341.c pt8211.c
  group Library
    ../library/STM32F4xx_Libraries/STM32_USB_OTG_Driver/src/: usb_core.c usb_hcd.c usb_hcd_int.c
    ../library/STM32F4xx_Libraries/STM32_USB_HOST_Library/Core/src/: usbh_core.c usbh_hcs.c usbh_ioreq.c usbh_stdreq.c
    ../library/STM32F4xx_Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group Startup
    ../startup/: startup.c startup_stm32f4xx.s system_stm32f4xx.c
  group OS_Kernel
    ../os/rtthread/src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c module.c object.c scheduler.c thread.c timer.c
  group OS_Port
    ../os/rtthread/libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
    ../os/rtthread/libcpu/arm/common/: backtrace.c div0.c showmem.c
  group OS_Comp_Drivers
    ../os/rtthread/components/drivers/i2c/: i2c_core.c i2c_dev.c i2c-bit-ops.c
    ../os/rtthread/components/drivers/serial/: serial.c
    ../os/rtthread/components/drivers/spi/: spi_core.c spi_dev.c
    ../os/rtthread/components/drivers/src/: completion.c dataqueue.c pipe.c portal.c ringbuffer.c
  group OS_Comp_Finsh
    ../os/rtthread/components/finsh/: shell.c symbol.c cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_var.c finsh_vm.c finsh_token.c
    ../OS/rtthread/components/init/: components.c
  group OS_Common
    ../os/common/: cv_osal_debug.c cv_osal_dmem.c
target Release (ARM-ADS)
  device: STM32F405RG STMicroelectronics
  cpu: as above
  output: Cygnoides
  AfterMake: fromelf --bin !L --output ..\BIN\CMS.BIN
  c flags: Optim=4 wLevel=2
  c define: STM32F4XX,STM32F405xx,USE_STDPERIPH_DRIVER,USE_USB_OTG_FS,NDEBUG
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: as above
